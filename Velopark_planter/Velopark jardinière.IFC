Properties of the parts of a building model (IFC2X3)

# File
Description: IFC2X3
File name: Velopark jardinière.IFC
Time: 2020-07-03T11:38:52
Written by: SwIFC
Made in: SolidWorks 2019

# IfcSite, Default Site
RefLatitude: 0, 0, 0, 0; RefLongitude: 0, 0, 0, 0; RefElevation: 0

# IfcBuildingStorey, Default Storey
In: Default Building
Elevation: 0

# IfcBeam: VPRK-MOD-JAR-002_Default
In: Default Storey
Material: Polyéthylène réticulé

# IfcBeam: VPRK-MOD-JAR-005_Default
In: Default Storey
Material: S 235

# IfcBuildingElementProxy: VPRK-MOD-JAR-003_Default
In: Default Storey
Material: S 235
PSet_Mass_Property - Mass Measure: 26.2209; Area Measure: 2.98123; Volume Measure: 0.00407333

# IfcBuildingElementProxy: VPRK-MOD-JAR-005_Default
In: Default Storey
Material: S 235
